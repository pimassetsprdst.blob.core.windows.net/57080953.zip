Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-06-14T17:24:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 14 17:24:49 2023 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\759ee022-3bab-4bb7-b5d6-2821236c801b\b7b18786-0596-404b-b607-1a6bf9b32221\ifc * Database version: 5507 * Database creation date: Wed Jun 14 17:24:49 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 14 17:24:49 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 14 17:24:49 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowController: 44350300 Hand shower, d 110 mm, 44350300(2023):44350300 Hand shower, d 110 mm:353704
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 50.1 mm; NominalHeight: 257.2 mm; NominalWidth: 109.8 mm
Type - General - Author: BIMStone; BIMObjectName: 44350300(2023); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 4057304017957; EN Standard: EN1112; ETIM Class Number: EC010161 Hand shower; Noise Class: I (ISO 3822); Noise Class 02ls: I (ISO 3822); UNSPSC Class Number: 30181803 Hand held shower unit; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/44350300; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach; URL UWL: http://static.hansa.com/UWL/44350300
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/44350300; 3D View: https://static.hansa.com/AR/44350300; Catalog Drawing URL: http://static.hansa.com/catdrw/44350300; Dimension Drawing URL: http://static.hansa.com/dimdrw/44350300; FDV Document URL: http://www.hansa.com/datasheet/44350300/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/44350300; Group: Hand shower; Installation and Maintenance Guide URL: http://static.hansa.com/manual/44350300; Interactive AR View URL: https://static.hansa.com/AR/44350300; Manufacturer: HANSA; Market: Austria;Belgium;Czech Republic;Germany;Spain;France;International;Italy;Netherlands;Slovakia; Mobile Product Information URL: http://mpi.hansa.com/44350300; Model: 44350300 Hand shower, d 110 mm; Name_en: 44350300 Hand shower, d 110 mm; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 44350300; Product Family: HANSAVIVA Eco; Product Image URL: http://static.hansa.com/image/44350300; Product URL: http://static.hansa.com/44350300; Technical DataSheet URL: http://www.hansa.com/datasheet/44350300/en; Type Name: 44350300 Hand shower, d 110 mm; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Connection Size: G1/2; Flow Rate At 300kPa With Flow Controller: 0.0052972 m3/s; Hand Shower Size: Ø110; Max. Hot Water Supply: 65 kg/K/s3; Shower Parts: Anti limescale technology (easy to clean); Shower Spray: Normal;Massage;Rain; Shower Spray Number: 3 shower sprays; Surface treatment: Chrome; Working Pressure: 50 - 500 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 44350300(2023); Features: n/a; Finish: Polished; Grade: n/a; Material: Composite; ModelNumber: n/a; ModelReference: 44350300; Name: 44350300 Hand shower, d 110 mm; ReplacementCost: n/a; Shape: Sculptured; Size: 95 x 60 x 245 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0466152 m2; Volume: 0.00141422 m3
Identity Data - Mark: 24
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 44350300(2023): 44350300 Hand shower, d 110 mm; Family and Type: 44350300(2023): 44350300 Hand shower, d 110 mm; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 44350300(2023): 44350300 Hand shower, d 110 mm; Type Id: 44350300(2023): 44350300 Hand shower, d 110 mm; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
